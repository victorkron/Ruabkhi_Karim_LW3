# IAR project STM32L-Discovery.ewp, settings and files
configuration STM32L152RC (32L152C-DISCOVERY) (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152ZC ST STM32L152ZC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; TSLPRM_STM32L1XX_SW_ACQ; STM32L1XX_MDP
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\Utilities\STM32L-DISCOVERY; ..\..\..\libraries\STM32L1xx_StdPeriph_Driver\inc; ..\..\..\libraries\STMTouch_Driver\inc; ..\..\..\libraries\CMSIS\Device\ST\STM32L1xx\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32L-Discovery.hex
  ILINK.IlinkOutputFile: STM32L-Discovery.out
  ILINK.IlinkIcfFile: stm32l1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32L152RB (STM32L-DISCOVERY) (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L152VB ST STM32L152VB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32L1XX_MD; USE_STDPERIPH_DRIVER
  group CMSIS
    ../src/: system_stm32l1xx.c
  group Doc
    ../: readme.txt
  group EWARM
    ../../../Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/iar/: startup_stm32l1xx_md.s startup_stm32l1xx_mdp.s
  group STM32L-Discovery
    ../../../Utilities/STM32L-DISCOVERY/: stm32l_discovery_lcd.c
  group STM32L1xx_StdPeriph_Driver
    ../../../Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_gpio.c stm32l1xx_lcd.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_syscfg.c
  group TouchSensingDriver
    ../../../Libraries/STMTouch_Driver/src/: tsl.c tsl_acq.c tsl_acq_stm32l1xx_sw.c tsl_dxs.c tsl_ecs.c tsl_filter.c tsl_globals.c tsl_linrot.c tsl_object.c tsl_time.c tsl_time_stm32l1xx.c tsl_touchkey.c
  group User
    ../src/: discover_functions.c icc_measure.c icc_measure_Ram.c main.c stm32l1xx_it.c tsl_user.c
